# IAR project Backup of LQ_KL46_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_KL46Z256
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LQ_KL46_Project.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\Administrator\桌面\KL系列单片机\LQ_KL46Z256_Project\src\Project_Settings\Link\LQ_KL46_256KBPflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Project_Setting/Link
    src/Project_Settings/Link/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
  group Project_Setting/Starup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Soures/C
    src/Sources/C/: isr.c main.c
    src/Sources/H/: isr.h
  group Soures/C/Component_C
    src/Sources/C/Component_C/: KL46_ADC0.c KL46_GPIO.c KL46_IIC.c KL46_LPT.c KL46_PIT.c KL46_PTM.c KL46_Uart.c KL46_Wdog.c LQ_KL46_Light.c LQ_KL46_MMA845X_Test.C LQ_KL46_OLED_12864_T.c LQ_KL46_TSL1401_Test.c
  group Soures/C/Frame_C
    src/Sources/C/Frame_C/: common.c printf.c sysinit.c vectors.c
  group Soures/H/Component_H
    src/Sources/H/Component_H/: KL46_ADC0.h KL46_GPIO.h KL46_IIC.h KL46_LPT.h KL46_PIT.h KL46_PTM.h KL46_Uart.h KL46_Wdog.h LQ_KL46_Light_Test.h LQ_KL46_MMA845X_Test.h LQ_KL46_OLED_12864_T.h LQ_KL46_TSL1401_Test.h
  group Soures/H/Frame_H
    src/Sources/H/Frame_H/: common.h MKL46Z4.h sysinit.h vectors.h
    src/Sources/H/: includes.h
