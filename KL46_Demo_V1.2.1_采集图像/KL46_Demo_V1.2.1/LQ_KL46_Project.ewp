# IAR project LQ_KL46_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_KL46Z256
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_KL46_Project.srec
  ILINK.IlinkOutputFile: LQ_KL46_Project.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\LQ_KL46_256KBPflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Project_Setting/Link
    src/Project_Settings/Link/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
  group Project_Setting/Starup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Soures/C
    src/Sources/C/: main.c
  group Soures/C/Component_C
    src/Sources/C/Component_C/: adc.c camera.c ccd.c DIPswitch.c dma.c gpio.c i2c.c KL46_light.c lptmr.c motor.c OLED_12864_T.c PID.c pit.c PTM.c steer.c uart.c wdog.c
    src/Sources/C/: fun.c
  group Soures/C/Frame_C
    src/Sources/C/Frame_C/: assert.c common.c printf.c sysinit.c vectors.c
    src/Sources/C/: global.c isr.c
  group Soures/H/Component_H
    src/Sources/H/Component_H/: adc.h camera.h ccd.h DIPswitch.h dma.h gpio.h i2c.h KL46_light.h lptmr.h motor.h OLED_12864_T.h PID.h pit.h PTM.h steer.h uart.h wdog.h
    src/Sources/H/: global.h
  group Soures/H/Frame_H
    src/Sources/H/Frame_H/: assert.h common.h MKL46Z4.h sysinit.h vectors.h
    src/Sources/H/: fun.h includes.h isr.h
